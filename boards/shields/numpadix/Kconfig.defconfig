## boards/shields/numpadix/Kconfig.defconfig
```kconfig
if SHIELD_NUMPADIX

config ZMK_KEYBOARD_NAME
    default "numpadix"

endif # SHIELD_NUMPADIX
```
